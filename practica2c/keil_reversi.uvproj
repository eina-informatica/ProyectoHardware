# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c gpio_hal.h timer_drv.c timer_drv.h planificador.c planificador.h cola.c cola.h io_reserva.h hello_world.c hello_world.h timer_hal.c timer_hal.h power.c power.h visualizar.c gestor_energia.c int_externas_hal.c alarmas.c botones.c visualizar.h gestor_energia.h int_externas_hal.h juego.c juego.h alarmas.h botones.h swi.h wd.h wd.c SWI.s linea_serie_drv.c linea_serie_hal.c linea_serie_drv.h linea_serie_hal.h celda.h tablero.h tablero.c config_conecta_K.h
